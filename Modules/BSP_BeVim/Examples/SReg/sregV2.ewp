# IAR project sregV2.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2274 MSP430F2274
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  ICC430.CCDefines: __MSP430F2274
  ICC430.CCOptLevel: 3
  group (top)
    ../../Sources/: beVim-CD4015.c beVim-clock-manager.c beVim-frequency.c beVim-gpios.c beVim-i2c.c beVim-mpu6000.c beVim-timerA.c beVim-uart.c
    ../../Includes/: beVim-CD4015.h beVim-clock-manager.h beVim-frequency.h beVim-gpios.h beVim-i2c.h beVim-mpu6000.h beVim-timerA.h beVim-uart.h
    ./: main.c
