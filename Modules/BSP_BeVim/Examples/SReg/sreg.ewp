# IAR project sreg.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2274 MSP430F2274
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: __MSP430F2274
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2274.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: main.c
  group Includes
    ../../Includes/: beVim-CD4015.h beVim-clock-manager.h beVim-frequency.h beVim-gpios.h beVim-i2c.h beVim-mpu6000.h beVim-timerA.h beVim-uart.h
  group Sources
    ../../Sources/: beVim-CD4015.c beVim-clock-manager.c beVim-frequency.c beVim-gpios.c beVim-i2c.c beVim-mpu6000.c beVim-timerA.c beVim-uart.c
